## as100esp8266/src/Kconfig
```kconfig
config AS100ESP8266
	tristate "Kernel module for ESP8266 spi device support on AS100GW"
	depends on SPI
```
